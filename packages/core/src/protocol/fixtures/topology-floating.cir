R1 a b 1k
.op
