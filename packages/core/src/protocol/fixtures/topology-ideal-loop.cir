V1 a 0 1
L1 a b 1m
V2 b 0 2
.op
