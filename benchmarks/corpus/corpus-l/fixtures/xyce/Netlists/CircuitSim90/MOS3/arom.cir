*mspice driven run, uid = 0.00000000
v$d5  57 0 exp(0.00000000000000e+00 4.50000000000000e+00
+0.00000000000000e+00 1.00000000000000e-09
+6.00000000000000e-07 1.00000000000000e-09)
v$d4  18 0 pulse(4.50000000000000e+00 0.00000000000000e+00
+7.00000000000000e-08 2.00000000000000e-09
+2.00000000000000e-09 2.96000000000000e-07 4.00000000000000e-07)
v$d3  10 0 pulse(0.00000000000000e+00 4.50000000000000e+00
+3.00000000000000e-08 2.00000000000000e-09
+2.00000000000000e-09 9.60000000000000e-08 2.00000000000000e-07)
v$d2  21 0 pulse(4.50000000000000e+00 0.00000000000000e+00
+5.20000000000000e-08 2.00000000000000e-09
+2.00000000000000e-09 4.20000000000000e-08 9.99999900000000e-08)
v$d1  23 0 pulse(4.50000000000000e+00 0.00000000000000e+00
+2.00000000000000e-09 2.00000000000000e-09
+2.00000000000000e-09 4.20000000000000e-08 9.99999900000000e-08)
mnd#/mp1 47 13 57 57 pn2 w=21u l=2u ad=126p as=126p
mnd#/mp2 47 25 57 57 pn2 w=21u l=2u ad=126p as=126p
mnd#/mp3 47 57 57 57 pn2 w=21u l=2u ad=126p as=126p
m$615 30 57 57 57 pn2 w=37u l=2u ad=185p as=185p
m$614 30 57 57 57 pn2 w=37u l=2u ad=185p as=185p
m$613 30 52 57 57 pn2 w=37u l=2u ad=185p as=185p
m$612 37 16 38 57 pn2 w=17u l=2u ad=85p as=85p
m$611 37 28 45 57 pn2 w=17u l=2u ad=85p as=85p
m$610 53 33 55 57 pn2 w=9u l=2u ad=54p as=54p
m$609 53 52 40 57 pn2 w=9u l=2u ad=54p as=54p
m$608 45 0 0 0 nn2 w=17u l=2u ad=102p as=102p
m$607 45 48 0 0 nn2 w=17u l=2u ad=102p as=102p
m$606 29 18 0 0 nn2 w=37u l=2u ad=185p as=185p
m$605 29 22 0 0 nn2 w=37u l=2u ad=185p as=185p
m$604 32 15 0 0 nn2 w=37u l=2u ad=185p as=185p
m$603 32 13 0 0 nn2 w=37u l=2u ad=185p as=185p
m$602 36 22 0 0 nn2 w=50u l=2u ad=300p as=300p
m$601 36 13 0 0 nn2 w=50u l=2u ad=300p as=300p
m$600 34 10 0 0 nn2 w=37u l=2u ad=185p as=185p
m$599 34 20 0 0 nn2 w=37u l=2u ad=185p as=185p
mnd#/mn3 3 57 0 0 nn2 w=37u l=2u ad=185p as=185p
mnd#/mn2 4 25 3 0 nn2 w=37u l=2u ad=185p as=185p
mnd#/mn1 47 13 4 0 nn2 w=37u l=2u ad=185p as=185p
m$598 1 52 0 0 nn2 w=37u l=2u ad=185p as=185p
m$597 2 57 1 0 nn2 w=37u l=2u ad=185p as=185p
m$596 30 57 2 0 nn2 w=37u l=2u ad=185p as=185p
m$595 37 22 38 0 nn2 w=9u l=2u ad=54p as=54p
m$594 37 14 45 0 nn2 w=9u l=2u ad=54p as=54p
m$593 53 51 55 0 nn2 w=17u l=2u ad=102p as=102p
m$592 53 31 40 0 nn2 w=6u l=2u ad=36p as=36p
rs#1 48 44 100k
rs#2 17 39 100k
mp13 50 22 57 57 pn2 w=10u l=2u ad=60p as=60p
mp47 50 35 57 57 pn2 w=2u l=6u ad=24p as=24p
mp10 57 24 57 57 pn2 w=1930u l=2u ad=8000p as=8000p
mp3 25 24 57 57 pn2 w=10u l=2u ad=60p as=60p
mp57 25 43 57 57 pn2 w=2u l=6u ad=24p as=24p
mp20 57 54 57 57 pn2 w=1775u l=2u ad=7200p as=7200p
mp23 55 54 57 57 pn2 w=18u l=2u ad=90p as=90p
mp37 55 27 57 57 pn2 w=2u l=6u ad=24p as=24p
m$591 38 39 57 57 pn2 w=17u l=2u ad=85p as=85p
m$590 11 46 57 57 pn2 w=90u l=2u ad=540p as=540p
m$589 46 17 57 57 pn2 w=34u l=2u ad=204p as=204p
m$588 17 37 57 57 pn2 w=17u l=2u ad=85p as=85p
m$587 14 28 57 57 pn2 w=146u l=2u ad=730p as=730p
m$586 27 55 57 57 pn2 w=6u l=2u ad=36p as=36p
m$585 28 29 57 57 pn2 w=146u l=2u ad=730p as=730p
m$584 12 47 57 57 pn2 w=98u l=2u ad=600p as=600p
m$583 48 53 57 57 pn2 w=17u l=2u ad=85p as=85p
m$582 40 44 57 57 pn2 w=9u l=2u ad=54p as=54p
m$581 54 42 57 57 pn2 w=392u l=2u ad=1960p as=1960p
m$580 42 13 57 57 pn2 w=98u l=2u ad=600p as=600p
m$579 41 13 57 57 pn2 w=4011u l=2u ad=24000p as=24000p
m$578 33 51 57 57 pn2 w=146u l=2u ad=730p as=730p
m$577 31 52 57 57 pn2 w=146u l=2u ad=730p as=730p
m$576 51 30 57 57 pn2 w=146u l=2u ad=730p as=730p
m$575 43 25 57 57 pn2 w=2u l=5u ad=30p as=30p
m$574 52 32 57 57 pn2 w=146u l=2u ad=730p as=730p
m$573 13 19 57 57 pn2 w=1752u l=2u ad=7000p as=7000p
m$572 19 49 57 57 pn2 w=292u l=2u ad=1460p as=1460p
m$571 49 50 57 57 pn2 w=73u l=2u ad=365p as=365p
m$570 35 50 57 57 pn2 w=2u l=5u ad=30p as=30p
m$569 24 36 57 57 pn2 w=196u l=2u ad=1200p as=1200p
m$568 26 56 57 57 pn2 w=146u l=2u ad=730p as=730p
m$567 56 34 57 57 pn2 w=146u l=2u ad=730p as=730p
m$566 22 16 57 57 pn2 w=73u l=2u ad=365p as=365p
m$565 20 15 57 57 pn2 w=292u l=2u ad=1460p as=1460p
m$564 16 23 57 57 pn2 w=73u l=2u ad=365p as=365p
m$563 15 21 57 57 pn2 w=146u l=2u ad=730p as=730p
m$562 45 0 9 57 pn2 w=17u l=2u ad=85p as=85p
m$561 9 48 57 57 pn2 w=17u l=2u ad=85p as=85p
m$560 29 18 8 57 pn2 w=73u l=2u ad=365p as=365p
m$559 8 22 57 57 pn2 w=73u l=2u ad=365p as=365p
m$558 32 15 7 57 pn2 w=73u l=2u ad=365p as=365p
m$557 7 13 57 57 pn2 w=73u l=2u ad=365p as=365p
m$556 36 22 6 57 pn2 w=98u l=2u ad=600p as=600p
m$555 6 13 57 57 pn2 w=98u l=2u ad=600p as=600p
m$554 34 10 5 57 pn2 w=73u l=2u ad=365p as=365p
m$553 5 20 57 57 pn2 w=73u l=2u ad=365p as=365p
mn3 0 15 0 0 nn2 w=480u l=2u ad=2400p as=2400p
mn11 50 15 0 0 nn2 w=5u l=2u ad=30p as=30p
mn12 50 0 0 0 nn2 w=45u l=2u ad=225p as=225p
mn33 0 56 0 0 nn2 w=672u l=2u
mn13 0 26 0 0 nn2 w=672u l=2u
mn21 25 26 0 0 nn2 w=5u l=2u ad=30p as=30p
mn2 25 0 0 0 nn2 w=45u l=2u ad=225p as=225p
mn1 55 12 0 0 nn2 w=18u l=2u ad=28p as=36p
mn14 55 0 0 0 nn2 w=2400u l=2u ad=3800p
mn10 0 12 0 0 nn2 w=1775u l=2u
m$552 38 39 0 0 nn2 w=9u l=2u ad=54p as=54p
m$551 11 46 0 0 nn2 w=50u l=2u ad=300p as=300p
m$550 46 17 0 0 nn2 w=18u l=2u ad=28p as=36p
m$549 17 37 0 0 nn2 w=9u l=2u ad=54p as=54p
m$548 14 28 0 0 nn2 w=74u l=2u ad=370p as=370p
m$547 27 55 0 0 nn2 w=6u l=2u ad=36p as=36p
m$546 28 29 0 0 nn2 w=74u l=2u ad=370p as=370p
m$545 12 47 0 0 nn2 w=42u l=2u ad=252p as=252p
m$544 48 53 0 0 nn2 w=9u l=2u ad=54p as=54p
m$543 40 44 0 0 nn2 w=6u l=2u ad=36p as=36p
m$542 54 42 0 0 nn2 w=200u l=2u ad=1000p as=1000p
m$541 42 13 0 0 nn2 w=50u l=2u ad=300p as=300p
m$540 41 13 0 0 nn2 w=7067u l=2u ad=42000p as=42000p
m$539 33 51 0 0 nn2 w=74u l=2u ad=370p as=370p
m$538 31 52 0 0 nn2 w=74u l=2u ad=370p as=370p
m$537 51 30 0 0 nn2 w=74u l=2u ad=370p as=370p
m$536 43 25 0 0 nn2 w=5u l=2u ad=30p as=30p
m$535 52 32 0 0 nn2 w=74u l=2u ad=370p as=370p
m$534 13 19 0 0 nn2 w=888u l=2u ad=3500p as=3500p
m$533 19 49 0 0 nn2 w=148u l=2u ad=740p as=740p
m$532 49 50 0 0 nn2 w=37u l=2u ad=185p as=185p
m$531 35 50 0 0 nn2 w=5u l=2u ad=30p as=30p
m$530 24 36 0 0 nn2 w=100u l=2u ad=500p as=500p
m$529 26 56 0 0 nn2 w=74u l=2u ad=370p as=370p
m$528 56 34 0 0 nn2 w=74u l=2u ad=370p as=370p
m$527 22 16 0 0 nn2 w=37u l=2u ad=185p as=185p
m$526 20 15 0 0 nn2 w=148u l=2u ad=740p as=740p
m$525 16 23 0 0 nn2 w=37u l=2u ad=185p as=185p
m$524 15 21 0 0 nn2 w=74u l=2u ad=370p as=370p
cphi2b 15 0 1.64p
cnphi2b 20 0 3.9p
cnphi1b 22 0 .9p
ca 56 0 .6p
cphi1b 16 0 .8p
cdnor 50 0 0.1p
cna 26 0 .6p
cnpchg 24 0 .6p
ccs 51 0 1.5p
cwle 13 0 .24p
cnor 25 0 0.1p
cmux 53 0 .1p
ccmuxen 52 0 1.5p
c$523 31 0 .5p
crow 41 0 0.01p
cncs 33 0 .8p
clatch 48 0 .2p
cnromen 28 0 0.75p
cromen 14 0 0.4p
cbit 55 0 .27p
cword 12 0 0.05p
comux 17 0 .05p
cyr 11 0 0.5p
* nominal 2 micron model 1e6 at 25c level 3
* ps:<sanca_models.cmos_iii>n2u1e6rb.lv3.1
.model nn2 nmos(
+ vto    =  2.0
+ uo     =  3.04837e+2
+ nsub   =  9.39336e+16
+ nfs    =  8.65380e+12
+ kappa  =  2.00000e-2
+ phi    =  1.10021e+0
+ theta  =  3.07932e-3
+ gamma  =  1.87627e+0
+ vmax   =  2.14653e+5
+ eta    =  6.77038e-1
+ tox    =  3.15000e-8
+ xj     =  3.00000e-7
+ tpg    =  1
+ js     =  7.65600e-5
+ cj     =  9.01001e-4
+ pb     =  9.67123e-1
+ rsh    =  4.07800e+1
+ level  =  3)
* seq no:     5  ta632-m  h1235a  w15  d1  2u  3nn  25c  1e6b  3/5/86
.model pn2 pmos(
+ vto    = -1.66902e+0
+ uo     =  2.96947e+2
+ kappa  =  2.00000e-2
+ nsub   =  6.15973e+15
+ nfs    =  2.13661e+12
+ gamma  =  6.16106e-1
+ phi    =  1.05277e+0
+ theta  =  1.18656e-1
+ vmax   =  3.01732e+5
+ eta    =  1.53195e+0
+ tox    =  3.15000e-8
+ xj     =  3.00000e-7
+ tpg    = -1
+ js     =  1.00000e-7
+ cj     =  2.39634e-4
+ pb     =  8.96557e-1
+ rsh    =  1.58600e+2
+ level  =  3)
* seq no:    14  ta632-m  h1235a  w02  d3  2u  3np  25c  1e6b  3/5/86
.ic v(53)=0.00000e+00  v(25)=0.00000e+00  v(50)=0.00000e+00
+v(55)=0.00000e+00  v(17)=0.00000e+00
.options device temp=2.70000000000000e+01
.print tran  PRECISION=10 WIDTH=19 v(57)  v(11) v(15) v(14) v(48) v(53) v(55) v(12) v(52) v(54)
*.print tran v(57) v(0) v(11) v(15) v(14) v(48) v(53) v(55) v(12) v(52) v(54)
.tran 1.00000000000000e-09 5.30000000000000e-07
*.options acct limpts=600
.end
