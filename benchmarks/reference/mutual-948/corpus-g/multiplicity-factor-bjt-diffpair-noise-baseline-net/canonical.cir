SIMPLE DIFFERENTIAL PAIR
VCC  7  0    12
VEE  8  0    -12
VIN  1  0 AC 1 0 SIN 0 1 1K 0 0 0
RS1  1  2    1K
RS2  6  0    1K
Q1   3  2  4 MOD1
Q1a   3  2  4 MOD1
Q1b   3  2  4 MOD1
Q1c   3  2  4 MOD1
Q1d   3  2  4 MOD1
Q1e   3  2  4 MOD1
Q2   5  6  4 MOD1
Q2a   5  6  4 MOD1
Q2b   5  6  4 MOD1
Q2c   5  6  4 MOD1
Q2d   5  6  4 MOD1
Q2e   5  6  4 MOD1
RC1  7  3    10K
RC2  7  5    10K
RE   4  8    10K
.MODEL MOD1 NPN BF=50 VAF=50 IS=1.E-12 RB=100 CJC=.5PF TF=.6NS

.noise V(3)  VIN oct 10 .01 1e3 1
.PRINT noise {sqrt(abs(inoise))} {sqrt(abs(onoise))}

.END
