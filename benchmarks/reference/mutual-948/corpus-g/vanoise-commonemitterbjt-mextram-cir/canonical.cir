* gnetlist -g spice-sdb CommonEmitterI.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
.noise V(OUT) V1 oct 10 .01 1e3 1

* Verify that case does not matter in the device names or noise type names
* for the DNO and DNI operators.
.print noise {log(onoise)} {log(inoise)}
+ {pow(abs(DNO(r3)),1/3)}
+ {pow(abs(DNO(r1)),1/3)}
+ {pow(abs(DNO(r5)),1/3)}
+ {pow(abs(DNO(r4)),1/3)}
+ {pow(abs(DNO(q1,White_noi_gnd)),1/3)}
+ {pow(abs(DNO(Q1,white_c2_B2)),1/3)}
+ {pow(abs(DNO(q1,white_b2_E1)),1/3)}
+ {pow(abs(DNO(q1,white_e_E1)),1/3)}
+ {pow(abs(DNO(q1,white_B_b1)),1/3)}
+ {pow(abs(DNO(q1,white_B1_b2)),1/3)}
+ {pow(abs(DNO(q1,flicker_B2_e1)),1/3)}
+ {pow(abs(DNO(q1,white_e1_B1)),1/3)}
+ {pow(abs(DNO(q1,flicker_e1_B1)),1/3)}
+ {pow(abs(DNO(q1,white_b1_C4)),1/3)}
+ {pow(abs(DNO(q1,Flicker_b1_c4)),1/3)}
+ {pow(abs(DNO(q1,White_b_c3)),1/3)}
+ {pow(abs(DNO(q1,Flicker_b_c3)),1/3)}
+ {pow(abs(DNO(q1,white_B1_s)),1/3)}
+ {pow(abs(DNO(q1,white_b_S)),1/3)}
+ {pow(abs(DNO(q1,white_C_c3)),1/3)}
+ {pow(abs(DNO(q1,white_c3_C4)),1/3)}
+ {pow(abs(DNO(q1,White_c4_c1)),1/3)}
+ {pow(abs(DNO(q1,white_C3_c1)),1/3)}
+ {pow(abs(DNO(q1,white_c_C4)),1/3)}
+ {pow(abs(DNO(q1,white_C_c1)),1/3)}
+ {pow(abs(DNO(Q1)),1/3)}
+ {pow(abs(DNO(r2)),1/3)}
+ {pow(abs(DNI(r3)),1/3)}
+ {pow(abs(DNI(r1)),1/3)}
+ {pow(abs(DNI(r5)),1/3)}
+ {pow(abs(DNI(r4)),1/3)}
+ {pow(abs(DNI(q1,white_Noi_gnd)),1/3)}
+ {pow(abs(DNI(q1,white_C2_b2)),1/3)}
+ {pow(abs(DNI(q1,white_B2_e1)),1/3)}
+ {pow(abs(DNI(q1,white_e_E1)),1/3)}
+ {pow(abs(DNI(q1,white_b_B1)),1/3)}
+ {pow(abs(DNI(q1,white_B1_b2)),1/3)}
+ {pow(abs(DNI(q1,flicker_b2_E1)),1/3)}
+ {pow(abs(DNI(q1,White_e1_b1)),1/3)}
+ {pow(abs(DNI(q1,Flicker_e1_b1)),1/3)}
+ {pow(abs(DNI(q1,white_B1_c4)),1/3)}
+ {pow(abs(DNI(q1,flicker_b1_C4)),1/3)}
+ {pow(abs(DNI(q1,white_B_c3)),1/3)}
+ {pow(abs(DNI(q1,Flicker_b_c3)),1/3)}
+ {pow(abs(DNI(q1,White_b1_s)),1/3)}
+ {pow(abs(DNI(q1,white_B_s)),1/3)}
+ {pow(abs(DNI(q1,white_c_C3)),1/3)}
+ {pow(abs(DNI(q1,white_C3_c4)),1/3)}
+ {pow(abs(DNI(q1,white_c4_C1)),1/3)}
+ {pow(abs(DNI(q1,White_c3_c1)),1/3)}
+ {pow(abs(DNI(q1,white_C_c4)),1/3)}
+ {pow(abs(DNI(q1,white_c_C1)),1/3)}
+ {pow(abs(DNI(q1)),1/3)}
+ {pow(abs(DNI(r2)),1/3)}

.options device temp=27

R5 0 OUT 1MEG
V1 1 0 sin 0 1 1meg AC 1
V2 Vcc 0 1.0
C2 Vc OUT 10u
R4 0 Ve 270
R3 Vc Vcc 1.5k
Q1 Vc Vb Ve 0 mymodel
.model mymodel npn level=504
+ LEVEL=504.0
+ TREF=25.00
+ DTA=0.000
+ EXMOD=1.000
+ EXPHI=1.000
+ EXAVL=0.000
+ EXSUB=0.000
+ IS=22.0E-18
+ IK=0.1
+ VER=2.5
+ VEF=44.0
+ BF=215.0
+ IBF=2.7E-15
+ MLF=2.000
+ XIBI=0.0
+ IZEB=0.0
+ NZEB=22.0
+ BRI=7.00
+ IBR=1.0E-015
+ VLR=0.2
+ XEXT=0.63
+ WAVL=1.1E-006
+ VAVL=3.0
+ SFH=0.3
+ RE=5.0
+ RBC=23.0
+ RBV=18.0
+ RCC=12.0
+ RCBLX=0.000
+ RCBLI=0.000
+ RCV=150.0
+ SCRCV=1250.0
+ IHC=4.000E-003
+ AXI=0.3
+ CJE=73.0E-015
+ VDE=950.0E-003
+ PE=400.0E-003
+ XCJE=400.0E-003
+ CBEO=0.000
+ CJC=78.0E-015
+ VDC=680.0E-003
+ PC=500.0E-003
+ XP=350.0E-003
+ MC=500.0E-003
+ XCJC=32.0E-003
+ CBCO=0.000
+ MTAU=1.0
+ TAUE=2.0E-012
+ TAUB=4.2E-12
+ TEPI=41.0E-12
+ TAUR=520.0E-012
+ DEG=0.01
+ XREC=0.1
+ AQBO=300.0E-003
+ AE=0.0E-003
+ AB=1.0
+ AEX=620.0E-003
+ AEPI=2.5
+ AC=2.0
+ ACBL=2.0
+ DAIS=0.000
+ DVGBF=50.0E-003
+ DVGBR=45.00E-003
+ VGB=1.17
+ VGC=1.18
+ VGJ=1.15
+ VGZEB=1.15
+ AVGEB=4.73E-4
+ TVGEB=636.0
+ DVGTE=50.0E-003
+ AF=2.000
+ KF=20.0E-012
+ KFN=20.0E-012
+ KAVL=1.000
+ ISS=48.0E-18
+ ICSS=-1.0
+ IKS=250.E-006
+ CJS=315.0E-015
+ VDS=620.0E-003
+ PS=340.0E-003
+ VGS=1.20
+ AS=1.580
+ ASUB=2.0
+ MULT=1.5
R2 0 Vb 6.8k
R1 Vb Vcc 39k
C1 1 Vb 10u
.end
